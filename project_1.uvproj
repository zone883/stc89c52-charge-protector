# Keil uVision project project_1.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Timer0.c Timer0.h Relay.c Relay.h Key.c Key.h DS18B20.c DS18B20.h OneWire.c OneWire.h INA219.c INA219.h I2C.c I2C.h MatrixLED.c MatrixLED.h
